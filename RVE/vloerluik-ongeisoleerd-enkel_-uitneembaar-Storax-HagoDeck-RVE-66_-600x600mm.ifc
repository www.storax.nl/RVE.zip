Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 422d3a52-c032-45ff-bab3-b65daadb8c04.ifc
Time: 2026-09-11T11:59:08
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck RVE 66, 600x600mm
In: Bouwlaag
Material: RVS
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAPTijLcDAAAAH1oBAAV2SgAA2FMBAFJfAQDxgwAA81kBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAPTijLcDAAAAH1oBAAV2SgAA2FMBAFJfAQDxgwAA81kBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAOw_AAAFeLkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 24 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 705 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 705 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 60 mm; merk: Storax; breuklast: A15; type: RVE 66; dagmaatbreedte: 600 mm; omranding: RVS; luik: RVS
